* Component: $UpdatedFiles/default.group/logic.views/HalfAdder  Viewpoint: eldonet
.INCLUDE HalfAdder_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX
