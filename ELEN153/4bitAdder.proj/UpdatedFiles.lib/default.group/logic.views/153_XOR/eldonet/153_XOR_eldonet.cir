* Component: $UpdatedFiles/default.group/logic.views/153_XOR  Viewpoint: eldonet
.INCLUDE 153_XOR_eldonet.spi

.OPTION NOASCII
.OPTION MODWL
.OPTION ENGNOT
.OPTION AEX
